# Keil uVision project MC-01_chassis.uvprojx, settings and files
target MC-01_chassis (6230000::V6.23::ARMCLANG)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MC-01_chassis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F446xx,__FPU_PRESENT = 1U,ARM_MATH_CM4,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Task/inc;../Driver/BMI088;../BSP/inc;../Drivers/CMSIS/DSP/Include;../Task;../Algorithm/inc;../Driver/UNITREE_A1;../Driver/Referee_System/inc
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
    ../Drivers/CMSIS/Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Task
    ../Task/: IMU_Task.c Monitor_Task.c Balance_Task.c Communicate_Task.c A1_Task.c LK9025_Task.c
    ../Task/inc/: Communicate_Task.h Configuration.h Monitor_Task.h INS_Task.h LK9025_Task.h A1_Task.h Balance_Task.h
  group BMI088_Driver
    ../Driver/BMI088/: BMI088driver.c BMI088Middleware.c
  group Bsp
    ../BSP/: Can_Bus.c Dwt_Timer.c universal.c RS485.c CRC.c Timers.c
    ../BSP/inc/: Can_Bus.h Dwt_Timer.h universal.h RS485.h
  group DSP_Lib
    ../Drivers/CMSIS/DSP/Source/FastMathFunctions/: arm_atan2_f32.c arm_cos_f32.c arm_sin_f32.c
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_add_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
  group Algorithm
    ../Algorithm/: PID.c QuaternionEKF.c kalman_filter.c
    ../Algorithm/inc/: PID.h QuaternionEKF.h kalman_filter.h
  group Device_Driver
    ../Driver/UNITREE_A1/: A1_Driver.c A1_Driver.h
software components: CMSIS:CORE 6.1.0
